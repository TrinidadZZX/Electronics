# Keil uVision project SPI.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SPI
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\STM32F10x_FWLib\inc;.\USER;.\APP;.\HARDWARE\LCD;.\HARDWARE\KEY;.\HARDWARE\LED;.\HARDWARE\sys;.\HARDWARE\OV7670;.\HARDWARE\USART2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./USER/: stm32f10x_it.c system_stm32f10x.c
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ./STM32F10x_FWLib/src/: stm32f10x_adc.c stm32f10x_spi.c stm32f10x_gpio.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c misc.c
  group APP
    ./APP/: main.c delay.c GUI.c test.c
  group HARDWARE
    ./HARDWARE/LCD/: lcd.c
    ./HARDWARE/KEY/: key.c
    ./HARDWARE/LED/: led.c
    ./HARDWARE/sys/: sys.c
    ./HARDWARE/OV7670/: exti.c ov7670.c sccb.c
    ./HARDWARE/USART2/: UART2.c
